# Repository Peize-Liu/Nxt-FC-Hardware (continued)

## KiCad design NxtPX4_Pro_V1.2.0_Release/NxtPX4.kicad_pcb

Board: 4 copper layers, 33.0 x 27.0 mm, 151 parts (73 on the bottom side), 127 nets.

Parts:
BOOT1: TD-1183SN-1.5H(3x2.5); 3x2.5PushButton
C1, C3, C12, C13: 22uF(0805 35V 20%); C_0805_2012Metric
C2: 10uF(0603 35V 20%); C_0603_1608Metric
C4, C8: 1uF(0402 35V 10%); C_0402_1005Metric
C5, C6, C9: 1uF(0402 16V 10%); C_0402_1005Metric
C7, C10, C16, C18, C19, C20, C33, C34, C37, C38, C39, C42, C48, C51: 100nF(0201 10V 10%); C_0201_0603Metric
C11: 100nF(0201 16V 10%); C_0201_0603Metric
C14, C15: 1uF(0402 10V 10%); C_0402_1005Metric
C17, C21: 100nF(0201 25V 10%); C_0201_0603Metric
C22: 100nF(0201 10.0V 10%); C_0201_0603Metric
C23, C24, C26: 22uF(0603 16V); C_0603_1608Metric
C27, C28, C50: 2.2uF(0402 6.3V 10%); C_0402_1005Metric
C29: 4.7uF(0402 10V); C_0402_1005Metric
C30: 15pF(0201 10V); C_0201_0603Metric
C31: 100nF(0201 6.3V); C_0201_0603Metric
C32: 1uF(0201 6.3V); C_0201_0603Metric
C35, C36: 12.0pF(0201 10V); C_0201_0603Metric
C44, C47: 100.0nF(0201 10V); C_0201_0603Metric
C45, C49: 100nF(0201 10V); C_0201_0603Metric
C52: 10nF(0201 10V 10%); C_0201_0603Metric
D1: PESD12VV1BL; PESD12VV1BL_315
D2, D4: PESD5V0F1BL
D3: SMF30CA(30V); D_SOD-123F
D5, D7: DSS34(3A 500mV); D_SOD-123F
D6: BZX584C9V1; D_SOD-523
D8, D9, D10, D11: LED_Blue(0201); LED_0201_0603Metric
D12: LED_RED(0201); LED_0201_0603Metric
D13: LED_BLUE(0201); LED_0201_0603Metric
D14: LED_Green(0201); LED_0201_0603Metric
H1, H2, H3, H4: MountingHole_Pad; M2MountingHole
J1: USB_C_Receptacle_USB2.0; USB_C_Small
J3: 9V_Power; Conn_1pin_Power
J4, J6, J10: ESC; 01x10_MP_sh1.0_Hori
J8: UART_Combo; 01x10_MP_sh1.0_Hori
J9: Upper computer connector; 01x04_MP_sh1.0_Hori
J24: Micro_SD_Card; TF-SMD_TF-021B-H265
J27: GND; Conn_1pin_Power
L1, L2: 10uH(0420)(78438357100); Inductor_0420
Q1: AP40P05; SOT-23
Q2, Q3: SS8050(NPN BEC); SOT-23
R1, R2: 5.1kR(0201); R_0201_0603Metric
R3, R8: 100kR(0201 50V); R_0201_0603Metric
R4, R6: 1MR(0402 50V); R_0402_1005Metric
R5, R7: 100kR(0201 25V); R_0201_0603Metric
R9, R11: 20R(0201 25V); R_0201_0603Metric
R10, R13: 51kR(0201 25V); R_0201_0603Metric
R12: 7.68kR(0201 25V); R_0201_0603Metric
R14, R18: 41.2kR(0201 25V); R_0201_0603Metric
R15: 200.0kR(0201 50V); R_0201_0603Metric
R16: 22.0kR(0201 50V); R_0201_0603Metric
R17: 3.54k-4.02kR(0201 25V); R_0201_0603Metric
R19, R20, R21, R26, R30, R31, R37, R38, R39, R40, R41: 10kR(0201); R_0201_0603Metric
R22: 20kR(0201 9V); R_0201_0603Metric
R23, R29: 1kR(0201); R_0201_0603Metric
R24, R25: 4.7kR(0201 25V); R_0201_0603Metric
R28: 100R(0201); R_0201_0603Metric
R32, R33, R34: 10.0kR(0201); R_0201_0603Metric
R35, R36: 4.7kR(0201); R_0201_0603Metric
TP1: 24V_TP; MiniTP
TP2: 3.3V_Core_TP; MiniTP
TP5: 3.3V_Peri_TP; MiniTP
TP9: 5V_System; MiniTP
TP12: CAM_9V; MiniTP
TP14, TP15, TP16: TP; MiniTP
U1, U4: MP9943GQ-Z
U2, U3: RT9013-33GB
U5: HKU_Logo
U6: UAV_LOGO; Uav_logo
U7: Direction_Logo
U8: RI_LOGO; Ri_logo
U9: STM32H743VIH6; STM32H743VIHBGA100C80P10X10_800X800X110N
U10: BMI088
U12: HiLAB_Logo; HILAB_Logo
U13: BMP388; PQFN50P200X200X80-10N
U14: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U15: Signature; my_signature
U16: High_temp; high_temp
U17: high_voltage
U18: Caution
U20: handsolder_connect
U21: ICM-20649
U22: ICM-42688-P
USART_Combo1: UART_Combo; 01x10_MP_sh1.0_Hori
Y1: SG-210STF/ X1G004171002700; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm
Y2: ABS07 (32.768kHZ); LSE(2012)

Connections:
/AUX_PC0: R28.2, U9.F1 (PC0)
/AUX_PC13: J6.3, U9.A2 (PC13)
/AUX_PD4: J6.1, U9.D7 (PD4)
/AUX_PH1: J6.2, U9.D1 (PH1-OSC_OUT)
/BAT_I: J10.7, U9.K4 (PB1)
/BAT_V: C22.1, R15.2, R16.1, U9.J4 (PB0)
/BMI_Accel_CS: U9.C3 (PE4), U10.14 (CSB1)
/BMI_Accel_Data_RDY: U9.C4 (PE1), U10.16 (INT1)
/BMI_Gryo_CS: U9.B3 (PE3), U10.5 (CSB2)
/BMI_Gyro_Data_RDY: U9.D4 (PE0), U10.12 (INT3)
/BMP_Data_RDY: U9.A4 (PB9), U13.7 (INT)
/Buzzer-: J4.8, Q3.3 (C)
/Buzzer_RGB_LED: J4.6, U9.E10 (PC7)
/Extern_I2C_INT_PE15: J4.3, U9.H7 (PE15)
/Extern_IMU_Heater: J4.7, U9.K5 (PE9)
/Extern_SPI_CS_1_PE13: J4.5, U9.K6 (PE13)
/Extern_SPI_CS_2_PE14: J6.5, U9.G7 (PE14)
/Extern_SPI_INT_1_PE10: J6.4, U9.G6 (PE10)
/Extern_SPI_INT_2_PE11: J4.4, U9.H6 (PE11)
/I2C1_SCL: R36.2, U9.B4 (PB8), U13.2 (SCK)
/I2C1_SDA: R35.2, U9.A5 (PB7), U13.4 (SDI)
/I2C2_SCL: J4.1, R24.1, U9.J7 (PB10)
/I2C2_SDA: J4.2, R25.1, U9.K7 (PB11)
/ICM_Data_RDY: U9.G3 (PA4), U22.4 (INT1/INT)
/ICM_~CS: U9.F3 (PC3_C), U22.12 (AP_CS)
/LED_BLUE: D13.2 (A), U9.G10 (PB15)
/LED_GREEN: D14.2 (A), U9.H10 (PB14)
/LED_RED: D12.2 (A), U9.F10 (PC6)
/MPU_Data_RDY: U9.H4 (PC5), U21.12 (INT1)
/MPU_~CS: U9.G4 (PC4), U21.22 (~CS)
/NRST: C33.1, R30.2, TP14.1, U9.E1 (NRST)
/PWM/DSHOT_CH1: J10.1, U9.G2 (PA0)
/PWM/DSHOT_CH2: J10.2, U9.H2 (PA1)
/PWM/DSHOT_CH3: J10.3, U9.J2 (PA2)
/PWM/DSHOT_CH4: J10.4, U9.K2 (PA3)
/PWM/DSHOT_CH5: J10.5, U9.H8 (PD14)
/PWM/DSHOT_CH6: J10.6, U9.G8 (PD15)
/QSPI_BK1_IO0: U9.G9 (PD11), U14.5 (DI(IO0))
/QSPI_BK1_IO1: U9.K10 (PD12), U14.2 (DO(IO1))
/QSPI_BK1_IO2: U9.A3 (PE2), U14.3 (IO2)
/QSPI_BK1_IO3: U9.J10 (PD13), U14.7 (IO3)
/QSPI_BK1_~CS: U9.B5 (PB6), U14.1 (~CS)
/QSPI_CLK: U9.G5 (PB2), U14.6 (CLK)
/SBUS: J8.3, R23.2
/SCLK: TP16.1, U9.A9 (PA14)
/SDMMC1_CK: J24.5 (CLK), U9.C8 (PC12)
/SDMMC1_CMD: J24.3 (CMD), R39.1, U9.B7 (PD2)
/SDMMC1_D0: J24.7 (DAT0), R40.1, U9.F9 (PC8)
/SDMMC1_D1: J24.8 (DAT1), R41.1, U9.E9 (PC9)
/SDMMC1_D2: J24.1 (DAT2), R37.1, U9.B9 (PC10)
/SDMMC1_D3: J24.2 (DAT3/CD), R38.1, U9.B8 (PC11)
/SPI1_MISO: U9.J3 (PA6), U21.9 (SDO)
/SPI1_MOSI: U9.K3 (PA7), U21.24 (SDI)
/SPI1_SCK: U9.H3 (PA5), U21.23 (SCLK)
/SPI2_MISO: U9.E2 (PC2_C), U22.1 (AP_SDO/AP_AD0)
/SPI2_MOSI: U9.F2 (PC1), U22.14 (AP_SDA/AP_SDIO/AP_SDI)
/SPI2_SCK: U9.C7 (PD3), U22.13 (AP_SCL/AP_SCLK)
/SPI3_MISO: U9.A6 (PB4), U10.10 (SDO2), U10.15 (SDO1)
/SPI3_MOSI: U9.C5 (PB5), U10.9 (SDI)
/SPI3_SCK: U9.A7 (PB3), U10.8 (SCK)
/SPI4_MISO: J6.6, U9.D3 (PE5)
/SPI4_MOSI: J6.7, U9.E3 (PE6)
/SPI4_SCK: J6.8, U9.J6 (PE12)
/SWDIO: TP15.1, U9.A10 (PA13)
/UART4_RX: J9.2, U9.D8 (PD0)
/UART4_TX: J9.1, U9.E8 (PD1)
/UART5_RX: J8.5, U9.K8 (PB12), U20.2 (NC)
/UART5_TX: J8.4, U9.J8 (PB13)
/UART7_RX: J8.7, U9.H5 (PE7)
/UART7_TX: J8.6, U9.J5 (PE8)
/USART1_CK: U9.D9 (PA8), USART_Combo1.10
/USART1_RX: U9.D10 (PA10), USART_Combo1.9
/USART1_TX: U9.C9 (PA9), USART_Combo1.8
/USART2_CK: U9.D6 (PD7), USART_Combo1.5
/USART2_RX: U9.C6 (PD6), USART_Combo1.4
/USART2_TX: U9.B6 (PD5), USART_Combo1.3
/USART3_CK: J8.10, U9.H9 (PD10)
/USART3_RX: J8.9, J10.8, U9.J9 (PD9)
/USART3_TX: J8.8, U9.K9 (PD8)
/USB_OTG_FS_DM: D2.2 (A2), J1.A7 (D-), J1.B7 (D-), U9.C10 (PA11)
/USB_OTG_FS_DP: D4.2 (A2), J1.A6 (D+), J1.B6 (D+), U9.B10 (PA12)
/VBUS: C9.1, C11.1, D1.2 (A2), D5.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
CAM_9V: C26.1, D11.2 (A), J3.1, L2.2, R18.2, TP12.1
Core_3V3: BOOT1.1, C14.1, C16.1, C19.1, C29.2, C31.1, C32.1, C34.1, C39.2, C44.1, C45.2, C47.1, C48.2, C49.1, C50.2, C51.2, C52.1, D8.2 (A), R24.2, R25.2, R26.1, R30.1, R35.1, R36.1, R37.2, R38.2, R39.2, R40.2, R41.2, TP2.1, U2.5 (VOUT), U9.A8 (PA15), U9.B2 (VBAT), U9.D2 (VDD), U9.F4 (VDDLDO), U9.F5 (VDD), U9.F6 (VDD33USB), U9.F7 (PDR_ON), U9.H1 (VDDA), U9.K1 (VDD), U10.3 (VDD), U10.11 (VDDIO), U13.1 (VDDIO), U13.6 (CSB), U13.10 (VDD), U21.8 (VDDIO), U21.13 (VDD), U22.5 (VDDIO), U22.8 (VDD), Y1.1 (~ST), Y1.4 (VCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, C26.2, C27.1, C28.1, C29.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.1, C42.2, C44.2, C45.1, C47.2, C48.1, C49.2, C50.1, C51.1, C52.2, D1.1 (A1), D2.1 (A1), D4.1 (A1), H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J4.9, J4.MP (MountPin), J6.9, J6.MP (MountPin), J8.2, J8.MP (MountPin), J9.4, J9.MP (MountPin), J10.9, J10.MP (MountPin), J24.6 (VSS), J24.9 (SHIELD), J27.1, Q2.2 (E), Q3.2 (E), R1.1, R2.1, R3.2, R8.2, R12.1, R16.2, R17.1, R19.1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
unnamed: C27.2, U9.E7 (VCAP)
unnamed: C28.2, U9.F8 (VCAP)
unnamed: C17.1, R9.2
unnamed: C21.1, R11.2
unnamed: D3.1 (A1), R3.1
unnamed: D6.2 (A), Q1.1 (G), R8.1
unnamed: D8.1 (K), R19.2
unnamed: D9.1 (K), R20.2
unnamed: D10.1 (K), R21.2
unnamed: D11.1 (K), R22.2
unnamed: D12.1 (K), R32.1
unnamed: D13.1 (K), R33.1
unnamed: D14.1 (K), R34.1
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.B5 (CC2), R1.2
unnamed: Q2.1 (B), R23.1
unnamed: Q2.3 (C), R26.2, U20.1 (NC)
unnamed: Q3.1 (B), R28.1, R29.2
unnamed: R10.2, R12.2, R14.1
unnamed: R13.2, R17.2, R18.1
unnamed: R9.1, U1.4 (BST)
unnamed: R4.2, U1.3 (EN/SYNC)
unnamed: R10.1, U1.1 (FB)
unnamed: R5.2, U1.8 (PG)
unnamed: C17.2, L1.1, U1.6 (SW)
unnamed: C7.1, R5.1, U1.2 (VCC)
unnamed: R11.1, U4.4 (BST)
unnamed: R6.2, U4.3 (EN/SYNC)
unnamed: R13.1, U4.1 (FB)
unnamed: R7.2, U4.8 (PG)
unnamed: C21.2, L2.1, U4.6 (SW)
unnamed: C10.1, R7.1, U4.2 (VCC)
unnamed: C35.1, U9.A1 (PC14-OSC32_IN), Y2.2
unnamed: C36.1, U9.B1 (PC15-OSC32_OUT), Y2.1
unnamed: BOOT1.2, R31.2, U9.D5 (BOOT0)
unnamed: C30.1, U9.C1 (PH0-OSC_IN), Y1.3 (OUT)
unnamed: C42.1, U21.10 (REGOUT)
Periph_3V3: C15.1, C18.1, C20.1, C37.1, C38.1, D9.2 (A), J24.4 (VDD), TP5.1, U3.5 (VOUT), U14.8 (VCC)
System_4V5: C5.1, C6.1, D5.1 (K), D7.1 (K), U2.1 (VIN), U2.3 (EN), U3.1 (VIN), U3.3 (EN)
System_5V: C23.1, C24.1, D7.2 (A), D10.2 (A), J4.10, J6.10, J8.1, J9.3, L1.2, R14.2, TP9.1, USART_Combo1.1, USART_Combo1.6
VCC_24V: C1.1, C2.1, C3.1, C4.1, C8.1, D6.1 (K), Q1.2 (S), R4.1, R6.1, R15.1, TP1.1, U1.7 (IN), U4.7 (IN)
VCC_BAT: C12.1, C13.1, D3.2 (A2), J10.10, Q1.3 (D)

File NxtPX4_Pro_V1.2.0_Release/production_v1.2.0_release/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BOOT1,3x2.5PushButton,1,TD-1183SN-1.5H(3x2.5),C231329
"C1, C12, C13, C3",805,4,22uF(0805 35V 20%),
"C10, C16, C18, C19, C20, C33, C34, C37, C38, C39, C42, C48, C51, C7",201,14,100nF(0201 10V 10%),
C11,201,1,100nF(0201 16V 10%),
"C14, C15",402,2,1uF(0402 10V 10%),
"C17, C21",201,2,100nF(0201 25V 10%),
C2,603,1,10uF(0603 35V 20%),
C22,201,1,100nF(0201 10.0V 10%),
"C23, C24, C26",603,3,22uF(0603 16V),
"C27, C28, C50",402,3,2.2uF(0402 6.3V 10%),
C29,402,1,4.7uF(0402 10V),
C30,201,1,15pF(0201 10V),
C31,201,1,100nF(0201 6.3V),
C32,201,1,1uF(0201 6.3V),
"C35, C36",201,2,12.0pF(0201 10V),
"C4, C8",402,2,1uF(0402 35V 10%),
"C44, C47",201,2,100.0nF(0201 10V),
"C45, C49",201,2,100nF(0201 10V),
"C5, C6, C9",402,3,1uF(0402 16V 10%),
C52,201,1,10nF(0201 10V 10%),
D1,PESD12VV1BL_315,1,PESD12VV1BL,
"D10, D11, D13, D8, D9",201,5,LED_Blue(0201),
D12,201,1,LED_RED(0201),
D14,201,1,LED_Green(0201),
"D2, D4",PESD5V0F1BL,2,PESD5V0F1BL,
D3,D_SOD-123F,1, SMF30CA(30V),
"D5, D7",D_SOD-123F,2,DSS34(3A 500mV),
D6,D_SOD-523,1,BZX584C9V1,
J1,USB_C_Small,1,USB_C_Receptacle_USB2.0,C963412
"J10, J4, J6",01x10_MP_sh1.0_Hori ,3,ESC,
J24,TF-SMD_TF-021B-H265,1,Micro_SD_Card,C498185
"J8, USART_Combo1",01x10_MP_sh1.0_Hori,2,UART_Combo,
J9,01x04_MP_sh1.0_Hori,1,Upper computer connector,
"L1, L2",Inductor_0420,2,10uH(0420)(??? 78438357100),C2655439
Q1,SOT-23,1,AP40P05,
"Q2, Q3",SOT-23,2,SS8050(NPN BEC),
"R1, R2",201,2,5.1kR(0201),
"R10, R13",201,2,51kR(0201 25V),
"R11, R9",201,2,20R(0201 25V),
R12,201,1,7.68kR(0201 25V),
"R14, R18",201,2,41.2kR(0201 25V),
R15,201,1,200.0kR(0201 50V),
R16,201,1,22.0kR(0201 50V),
R17,201,1,3.54k-4.02kR(0201 25V),
"R19, R20, R21, R26, R30, R31, R37, R38, R39, R40, R41",201,11,10kR(0201),
R22,201,1,20kR(0201 9V),
"R23, R29",201,2,1kR(0201),
"R24, R25",201,2,4.7kR(0201 25V),
R28,201,1,100R(0201),
"R3, R8",201,2,100kR(0201 50V),
"R32, R33, R34",201,3,10.0kR(0201),
"R35, R36",201,2,4.7kR(0201),
"R4, R6",402,2,1MR(0402 50V),
"R5, R7",201,2,100kR(0201 25V),
"U1, U4",MP9943GQ-Z,2,MP9943GQ-Z,
U10,BMI088,1,BMI088,
U13,PQFN50P200X200X80-10N,1,BMP388,
U14,SOIC-8_5.23x5.23mm_P1.27mm,1,W25Q128JVS,
"U2, U3",RT9013-33GB,2,RT9013-33GB,
U20,handsolder_connect,1,~,
U21,ICM-20649,1,~,
U22,ICM-42688-P,1,ICM-42688-P,
U9,STM32H743VIHBGA100C80P10X10_800X800X110N,1,STM32H743VIH6,
Y1,Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm,1,SG-210STF/ X1G004171002700,C255993
Y2,LSE(2012),1,ABS07 (32.768kHZ),

## KiCad design NxtPX4_V1.0/NxtPX4.kicad_pcb

Parts:
BOOT1: TD-1183SN-1.5H(3x2.5); 3x2.5PushButton
C1: 22uF(0805 50V); C_0805_2012Metric
C2, C4: 10uF(0603 50V); C_0603_1608Metric
C3, C15: 10nF(0402 50V); C_0402_1005Metric
C5: 1uF(0402 50V); C_0402_1005Metric
C6, C7, C8, C9, C12, C13, C14, C25: 100nF(0402 16V); C_0402_1005Metric
C10: 1uF(0402 16V); C_0402_1005Metric
C11, C28, C39, C44, C49: 100nF(0402); C_0402_1005Metric
C16, C17, C19: 1uF(0402 10V); C_0402_1005Metric
C18, C20, C21, C22, C23, C24, C36, C40, C42, C46, C48, C51: 100nF(0402 10V); C_0402_1005Metric
C26, C27: 22uF(0603 16V); C_0603_1608Metric
C29, C30, C43: 2.2uF(0402 10V); C_0402_1005Metric
C31: 4.7uF(0402 10V); C_0402_1005Metric
C32: 15pF(0402 10V); C_0402_1005Metric
C33: 1.0uF(0402 10V); C_0402_1005Metric
C34: 100nF(0201 10V); C_0201_0603Metric
C35: 1uF(0201 10V); C_0201_0603Metric
C37, C38: 12.0pF(0201 10V); C_0201_0603Metric
C41: 10nF(0402); C_0402_1005Metric
C45: 10nF(0402 10V); C_0402_1005Metric
C47, C50: 100.0nF(0402 10V); C_0402_1005Metric
D1: PESD12VV1BL; PESD12VV1BL_315
D2, D3: PESD5V0F1BL
D4: BZX584C9V1; D_SOD-523
D5, D6: DSS34; D_SOD-123F
D7, D8, D9: LED_G(0201); LED_0201_0603Metric
D10: LED_RED(0201); LED_0201_0603Metric
D11: LED_BLUE(0201); LED_0201_0603Metric
D12: LED_GREEN(0201); LED_0201_0603Metric
FID1: Mark1; Fidiucial
FID2: Mark2; Fidiucial
FID3: Mark3; Fidiucial
H1, H2, H3, H4: MountingHole_Pad; M2MountingHole
J1: USB_C_Receptacle_USB2.0; USB-C-16p
J2, J7: Conn_01x04; Conn_4Pin
J4, J5, J6: Conn_01x03; Conn_3pin
J8: Conn_01x14; Conn_14pin
J9: UART4(sh1.0 4pin); JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J10: ESC sh1.0 8pin; JST_SH_SM08B-SRSS-TB_1x08-1MP_P1.00mm_Horizontal
J11: Micro_SD_Card; TF-SMD_TF-021B-H265
L1: 10uH(0420); Inductor_0420
Q1: AP40P05; SOT-23
R1, R9: 33R(0402); R_0402_1005Metric
R2, R3: 5.1kR(0201); R_0201_0603Metric
R4: 100kR(0201); R_0201_0603Metric
R5, R6, R29: 0R(0201); R_0201_0603Metric
R7: 1mR(0201); R_0201_0603Metric
R8: 100kR(0402); R_0402_1005Metric
R10: 20R(0402); R_0402_1005Metric
R11: 51kR(0402); R_0402_1005Metric
R12: 7.68kR(0402); R_0402_1005Metric
R13: 41.2kR(0402); R_0402_1005Metric
R14: 200.0kR(0201); R_0201_0603Metric
R15: 22.0kR(0201); R_0201_0603Metric
R16, R17, R18, R24, R26, R30, R31, R32, R33, R34: 10kR(0201); R_0201_0603Metric
R19, R20, R27, R28: 4.7kR(0201); R_0201_0603Metric
R21, R22, R23: 10.0kR(0201); R_0201_0603Metric
R25: 0.0R(0402); R_0402_1005Metric
RST1: TD-1183SN-1.5H(3x2.5); 3x2.5PushButton
TP5: 24V_TP; MiniTP
TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13: MP; PWR_Circle
TP14, TP15: 3.3V_Core_TP; MiniTP
TP16: 3.3V_Peri_Device_TP; MiniTP
TP17, TP18: TestPoint; Conn_1pin
TP19, TP20, TP21, TP22: TestPoint; MiniTP
TP23, TP24: PIN; Conn_1pin
TP25, TP26: 5V_TP; Conn_1pin
TP27, TP28: GND_TP; Conn_1pin
TP29, TP30, TP31, TP32: TP; MiniTP
U1, U2, U3: RT9013-33GB
U4: MP9943GQ-Z
U5: Direction_Logo
U6: STM32H743VIH6; STM32H743VIHBGA100C80P10X10_800X800X110N
U7: MPU6500; QFN-24-1EP_3x3mm_P0.4mm_EP1.75x1.6mm
U8: ICM-20602; LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y
U9: BMP388; PQFN50P200X200X80-10N
U10: BMI088
U11: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
Y1: SG-210STF; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm
Y2: ABS07 (32.768kHZ); LSE(2012)

Connections:
/AUX_PA15: TP21.1, U6.A8 (PA15)
/AUX_PC0: TP19.1, U6.F1 (PC0)
/AUX_PC13: TP23.1, U6.A2 (PC13)
/AUX_PD4: TP20.1, U6.D7 (PD4)
/AUX_PH1: TP22.1, U6.D1 (PH1-OSC_OUT)
/BAT_I: J10.5, U6.K4 (PB1)
/BAT_V: C28.1, R14.2, R15.1, U6.J4 (PB0)
/BMI_Accel_CS: U6.C3 (PE4), U10.14 (CSB1)
/BMI_Accel_Data_RDY: U6.C4 (PE1), U10.16 (INT1)
/BMI_Gryo_CS: U6.B3 (PE3), U10.5 (CSB2)
/BMI_Gyro_Data_RDY: U6.D4 (PE0), U10.12 (INT3)
/BMP_Data_RDY: U6.A4 (PB9), U9.7 (INT)
/Buzzer: TP24.1, U6.E10 (PC7)
/Extern_I2C_INT: J8.6, U6.H7 (PE15)
/Extern_IMU_Heater: J8.3, U6.K5 (PE9)
/Extern_SPI_CS_1: J8.13, U6.K6 (PE13)
/Extern_SPI_CS_2: J8.10, U6.G7 (PE14)
/Extern_SPI_INT_1: J8.2, U6.G6 (PE10)
/Extern_SPI_INT_2: J8.11, U6.H6 (PE11)
/I2C1_SCL: R28.2, U6.B4 (PB8), U9.2 (SCK)
/I2C1_SDA: R27.2, U6.A5 (PB7), U9.4 (SDI)
/I2C2_SCL: J8.14, R19.1, U6.J7 (PB10)
/I2C2_SDA: J8.7, R20.1, U6.K7 (PB11)
/ICM_Data_RDY: U6.G3 (PA4), U8.6 (INT)
/ICM_~CS: U6.F3 (PC3_C), U8.5 (~CS)
/LED_BLUE: D11.2 (A), U6.G10 (PB15)
/LED_GREEN: D12.2 (A), U6.H10 (PB14)
/LED_RED: D10.2 (A), U6.F10 (PC6)
/MPU_Data_RDY: U6.H4 (PC5), U7.12 (INT)
/MPU_~CS: U6.G4 (PC4), U7.22 (nCS)
/NRST: C33.1, R24.2, RST1.2, TP32.1, U6.E1 (NRST)
/PWM/DSHOT_CH1: J10.1, U6.G2 (PA0)
/PWM/DSHOT_CH2: J10.2, U6.K2 (PA3)
/PWM/DSHOT_CH3: J10.3, U6.J2 (PA2)
/PWM/DSHOT_CH4: J10.4, U6.H2 (PA1)
/PWM/DSHOT_CH5: TP18.1, U6.H8 (PD14)
/PWM/DSHOT_CH6: TP17.1, U6.G8 (PD15)
/QSPI_BK1_IO0: U6.G9 (PD11), U11.5 (DI(IO0))
/QSPI_BK1_IO1: U6.K10 (PD12), U11.2 (DO(IO1))
/QSPI_BK1_IO2: U6.A3 (PE2), U11.3 (IO2)
/QSPI_BK1_IO3: U6.J10 (PD13), U11.7 (IO3)
/QSPI_BK1_~CS: U6.B5 (PB6), U11.1 (~CS)
/QSPI_CLK: U6.G5 (PB2), U11.6 (CLK)
/SCLK: TP30.1, U6.A9 (PA14)
/SDMMC1_CK: J11.5 (CLK), U6.C8 (PC12)
/SDMMC1_CMD: J11.3 (CMD), R32.1, U6.B7 (PD2)
/SDMMC1_D0: J11.7 (DAT0), R33.1, U6.F9 (PC8)
/SDMMC1_D1: J11.8 (DAT1), R34.1, U6.E9 (PC9)
/SDMMC1_D2: J11.1 (DAT2), R30.1, U6.B9 (PC10)
/SDMMC1_D3: J11.2 (DAT3/CD), R31.1, U6.B8 (PC11)
/SPI1_MISO: U6.J3 (PA6), U7.9 (SDO)
/SPI1_MOSI: U6.K3 (PA7), U7.24 (SDI)
/SPI1_SCK: U6.H3 (PA5), U7.23 (SCLK)
/SPI2_MISO: U6.E2 (PC2_C), U8.4 (SAO/SD0)
/SPI2_MOSI: U6.F2 (PC1), U8.3 (SDA/SDI)
/SPI2_SCK: U6.C7 (PD3), U8.2 (SCL/SPC)
/SPI3_MISO: U6.A6 (PB4), U10.10 (SDO2), U10.15 (SDO1)
/SPI3_MOSI: U6.C5 (PB5), U10.9 (SDI)
/SPI3_SCK: U6.A7 (PB3), U10.8 (SCK)
/SPI4_MISO: J8.12, U6.D3 (PE5)
/SPI4_MOSI: J8.9, U6.E3 (PE6)
/SPI4_SCK: J8.5, U6.J6 (PE12)
/SWDIO: TP29.1, U6.A10 (PA13)
/UART4_RX: J9.2, U6.D8 (PD0)
/UART4_TX: J9.1, U6.E8 (PD1)
/UART5_RX: J2.2, U6.K8 (PB12)
/UART5_TX: J2.1, U6.J8 (PB13)
/UART7_RX: J2.4, J10.7, U6.H5 (PE7)
/UART7_TX: J2.3, U6.J5 (PE8)
/USART1_CK: J5.2, U6.D9 (PA8)
/USART1_RX: J5.3, U6.D10 (PA10)
/USART1_TX: J5.1, U6.C9 (PA9)
/USART2_CK: J6.3, U6.D6 (PD7)
/USART2_RX: J6.2, U6.C6 (PD6)
/USART2_TX: J6.1, U6.B6 (PD5)
/USART3_CK: J4.1, U6.H9 (PD10)
/USART3_RX: J4.2, U6.J9 (PD9)
/USART3_TX: J4.3, U6.K9 (PD8)
/USB_OTG_FS_DM: J7.2, R5.1, U6.C10 (PA11)
/USB_OTG_FS_DP: J7.3, R6.1, U6.B10 (PA12)
/VBUS: C6.1, C10.1, D1.2 (A2), D5.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J7.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.2, C29.1, C30.1, C31.1, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.1, C42.1, C43.1, C44.2, C45.2, C46.1, C47.2, C48.2, C49.2, C50.2, C51.2, D1.1 (A1), D2.1 (A1), D3.1 (A1), H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J7.4, J8.8, J9.4, J9.MP (Shield), J10.6, J10.MP (MountPin), J11.6 (VSS), J11.9 (SHIELD), R2.1, R3.1, R4.2, R12.1, R15.2, R16.1, R17.1, R18.1, R21.2, R22.2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
IMU_VCC: C17.1, C20.1, C23.1, C41.2, C42.2, C43.2, C45.1, C46.2, C47.1, C49.1, C50.1, C51.1, D8.2 (A), TP15.1, U1.5 (VOUT), U7.8 (VDDIO), U7.13 (VDD), U8.1 (VDDIO), U8.16 (VDD), U9.1 (VDDIO), U9.6 (CSB), U9.10 (VDD), U10.3 (VDD), U10.11 (VDDIO)
MCU_VCC: BOOT1.1, C16.1, C18.1, C21.1, C31.2, C36.1, D7.2 (A), R19.2, R20.2, R24.1, R25.1, R27.1, R28.1, R30.2, R31.2, R32.2, R33.2, R34.2, TP14.1, U3.5 (VOUT), U6.B2 (VBAT), U6.D2 (VDD), U6.F4 (VDDLDO), U6.F5 (VDD), U6.F6 (VDD33USB), U6.F7 (PDR_ON), U6.K1 (VDD), Y1.1 (#ST), Y1.4 (VCC)
unnamed: BOOT1.2, R26.2, U6.D5 (BOOT0)
unnamed: C3.1, R1.2
unnamed: C11.1, R8.1, U4.2 (VCC)
unnamed: C15.1, R9.1
unnamed: C25.1, R10.2
unnamed: C25.2, L1.1, U4.6 (SW)
unnamed: C26.1, C27.1, D6.2 (A), L1.2, R13.2
unnamed: C29.2, U6.E7 (VCAP)
unnamed: C30.2, U6.F8 (VCAP)
unnamed: C32.1, U6.C1 (PH0-OSC_IN), Y1.3 (OUT)
unnamed: C34.1, C35.1, R25.2, U6.H1 (VDDA)
unnamed: C37.1, U6.A1 (PC14-OSC32_IN), Y2.2
unnamed: C38.1, U6.B1 (PC15-OSC32_OUT), Y2.1
unnamed: C44.1, U7.10 (REGOUT)
unnamed: C48.1, U8.14 (REGOUT)
unnamed: D2.2 (A2), J1.A7 (D-), J1.B7 (D-), R5.2
unnamed: D3.2 (A2), J1.A6 (D+), J1.B6 (D+), R6.2
unnamed: D4.2 (A), Q1.1 (G), R4.1
unnamed: D7.1 (K), R16.2
unnamed: D8.1 (K), R17.2
unnamed: D9.1 (K), R18.2
unnamed: D10.1 (K), R21.1
unnamed: D11.1 (K), R22.1
unnamed: D12.1 (K), R23.1
unnamed: J1.A5 (CC1), R3.2
unnamed: J1.B5 (CC2), R2.2
unnamed: R7.2, U4.3 (EN/SYNC)
unnamed: R8.2, U4.8 (PG)
unnamed: R10.1, U4.4 (BST)
unnamed: R11.1, U4.1 (FB)
unnamed: R11.2, R12.2, R13.1
unnamed: R29.2, U9.5 (SDO)
Periph_VCC: C19.1, C22.1, C24.1, C39.1, C40.1, D9.2 (A), J11.4 (VDD), TP16.1, U2.5 (VOUT), U11.8 (VCC)
System_5V: C7.1, C8.1, C9.1, C12.1, C13.1, C14.1, D5.1 (K), D6.1 (K), J8.1, J8.4, J9.3, TP6.1, TP7.1, TP8.1, TP9.1, TP25.1, TP26.1, U1.1 (VIN), U1.3 (EN), U2.1 (VIN), U2.3 (EN), U3.1 (VIN), U3.3 (EN)
VCC_24V: C1.1, C2.1, C4.1, C5.1, D4.1 (K), Q1.2 (S), R7.1, R9.2, R14.1, TP5.1, U4.7 (IN)
VCC_BAT: J10.8, Q1.3 (D), R1.1

Notes on the sheet:
Baro I2C
BAT_Voltage_Detection
5V to MCU_VCC
IMU MPU
防反接
SDO To VSS ADDR:0x1110110 SDO To VDDIO ADDR:0x1110111 CSB To VDDIO In I2C Mode
冲击保护
3.3V 500mA
5V to Periph_VCC
此处的电流一般不会超过5A
IMU ICM SPI
IMU BMI088 SPI
5V 3A output
FRAM / QSPI
IO GH2.5
MCU
BAT power protection
SD_CARD
5V to IMU_VCC
Type-C power
2S-6S input to 5v
Typical Flight coontroller power mode
