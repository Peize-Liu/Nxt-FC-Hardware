# Repository Peize-Liu/Nxt-FC-Hardware

File README.md:

# NxtPX4-Hardware V2 Dual

* [English](# Getting start)
* [中文](# 配置指南)

## Getting start

### Hardware connection

### Compile PX4 bootloader

### Compile PX4 Firmware

### Config NxtPX4-Dual

## 配置指南

### 电控系统连接

### 编译PX4固件Bootloader

### 编译PX4固件

### 配置你的NxtPX4-Dual

## KiCad design NxtFC-DUAL/NxtPX4.kicad_pcb

Parts:
BOOT1: TD-1183SN-1.5H(3x2.5); 3x2.5PushButton
C1, C3, C12, C13: 22uF(0805 35V 20%); C_0805_2012Metric
C2: 10uF(0603 35V 20%); C_0603_1608Metric
C4, C8: 1uF(0402 35V 10%); C_0402_1005Metric
C5, C6, C9: 1uF(0402 16V 10%); C_0402_1005Metric
C7, C10, C16, C18, C19, C20, C33, C34, C37, C38, C39, C40, C43: 100nF(0201 10V 10%); C_0201_0603Metric
C11: 100nF(0201 16V 10%); C_0201_0603Metric
C14, C15: 1uF(0402 10V 10%); C_0402_1005Metric
C17, C21: 100nF(0201 25V 10%); C_0201_0603Metric
C22: 100nF(0201 10.0V 10%); C_0201_0603Metric
C23, C24, C26: 22uF(0603 16V); C_0603_1608Metric
C25: 10uF(0603 16V); C_0603_1608Metric
C27, C28: 2.2uF(0402 6.3V 10%); C_0402_1005Metric
C29: 4.7uF(0402 10V); C_0402_1005Metric
C30: 15pF(0201 10V); C_0201_0603Metric
C31: 100nF(0201 6.3V); C_0201_0603Metric
C32: 1uF(0201 6.3V); C_0201_0603Metric
C35, C36: 12.0pF(0201 10V); C_0201_0603Metric
C41, C42, C44, C45: 100.0nF(0201 10V); C_0201_0603Metric
D1: PESD12VV1BL; PESD12VV1BL_315
D2, D4: PESD5V0F1BL
D3: SMF30CA(30V); D_SOD-123F
D5, D7: DSS34(3A 500mV); D_SOD-123F
D6: BZX584C9V1; D_SOD-523
D8, D9, D10, D11: LED_Blue(0201); LED_0201_0603Metric
D12: LED_RED(0201); LED_0201_0603Metric
D13: LED_BLUE(0201); LED_0201_0603Metric
D14: LED_Green(0201); LED_0201_0603Metric
FID1: Mark1; Fidiucial
FID2: Mark2; Fidiucial
FID3: Mark3; Fidiucial
H1, H2, H3, H4: MountingHole_Pad; M2MountingHole
J1: USB_C_Receptacle_USB2.0; USB_C_Small
J2: DJIO3; 1x06-1MP_P1.00mm_Horizontal
J3: GPS; 1x06-1MP_P1.00mm_Horizontal
J4: UART2; 01x04_MP_sh1.0_Hori
J5, J7: Upper computer connector; 01x04_MP_sh1.0_Hori
J6: ESC; 01x08_MP_sh1.0_Hori
J8: PWM_AUX; 01x05_MP_sh1.0_Hori
J9: Conn_01x04; Conn_4Pin
J10: Micro_SD_Card; TF-SMD_TF-021B-H265
J11: Debug; 1x06-1MP_P1.00mm_Horizontal
J12: AuxGPIO; 1x06-1MP_P1.00mm_Horizontal
L1, L2: 10uH(0420)(78438357100); Inductor_0420
Q1: AP40P05; SOT-23
R1, R2: 5.1kR(0201); R_0201_0603Metric
R3, R5: 1MR(0402 50V); R_0402_1005Metric
R4, R6: 100kR(0201 25V); R_0201_0603Metric
R7: 100kR(0201 50V); R_0201_0603Metric
R8, R10: 20R(0201 25V); R_0201_0603Metric
R9, R12: 51kR(0201 25V); R_0201_0603Metric
R11: 7.68kR(0201 25V); R_0201_0603Metric
R13, R17: 41.2kR(0201 25V); R_0201_0603Metric
R14: 200.0kR(0201 50V); R_0201_0603Metric
R15: 22.0kR(0201 50V); R_0201_0603Metric
R16: 2.90k-4.02kR(0201 25V) / 3k for 12V; R_0201_0603Metric
R18, R19, R20, R23, R27, R28, R31, R32, R33, R34, R35, R38: 10kR(0201); R_0201_0603Metric
R21: 20kR(0201 9V); R_0201_0603Metric
R24, R25, R26, R29, R30, R36, R37: 10.0kR(0201); R_0201_0603Metric
TP1: 24V_TP; MiniTP
TP2: 3.3V_Core_TP; MiniTP
TP3, TP4, TP6, TP7, TP8, TP10, TP11, TP13: MP; PWR_Circle
TP5: 3.3V_Peri_TP; MiniTP
TP9: 5V_System; MiniTP
TP12: CAM_9V; MiniTP
U1, U4: MP9943GQ-Z
U2, U3: RT9013-33GB
U5: UAV_LOGO; Uav_logo
U6: Direction_Logo
U7: NxtLOGO
U8: Signature; my_signature
U9: high_voltage
U10: Caution
U11: STM32H743VIH6; STM32H743VIHBGA100C80P10X10_800X800X110N
U13: SPL06; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering
U14, U15: BMI088
U16: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U17: UAV_LOGO; Dual_logo
U19: SN74LVC1G86DCKR; DCK5
Y1: SG-210STF/ X1G004171002700; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm
Y2: ABS07 (32.768kHZ); LSE(2012)

Connections:
/ADC1_INP4_BATT_V: C22.1, R14.2, R15.1, U11.G4 (PC4)
/ADC2_INP8_BATT_I: J6.1, U11.H4 (PC5)
/AUX1_PC0: J12.3, U11.F1 (PC0)
/AUX2_PC1: J12.2, U11.F2 (PC1)
/AUX3_PA4: J12.1, U11.G3 (PA4)
/BMI088_0_ACS: U11.J2 (PA2), U15.14 (CSB1)
/BMI088_0_ADR: U11.G2 (PA0), U15.16 (INT1)
/BMI088_0_GCS: U11.K2 (PA3), U15.5 (CSB2)
/BMI088_0_GDR: U11.H2 (PA1), U15.12 (INT3)
/BMI088_0_MISO: U11.J3 (PA6), U15.10 (SDO2), U15.15 (SDO1)
/BMI088_0_MOSI: U11.K3 (PA7), U15.9 (SDI)
/BMI088_0_SCK: U11.H3 (PA5), U15.8 (SCK)
/BMI088_1_ACS: U11.A2 (PC13), U14.14 (CSB1)
/BMI088_1_ADR: U11.C3 (PE4), U14.16 (INT1)
/BMI088_1_GCS: U11.E2 (PC2_C), U14.5 (CSB2)
/BMI088_1_GDR: U11.B3 (PE3), U14.12 (INT3)
/BMI088_1_MISO: U11.D3 (PE5), U14.10 (SDO2), U14.15 (SDO1)
/BMI088_1_MOSI: U11.E3 (PE6), U14.9 (SDI)
/BMI088_1_SCK: U11.A3 (PE2), U14.8 (SCK)
/Baro_I2C1_DR: U11.C5 (PB5), U13.5 (SDO)
/Baro_I2C1_SCL: R36.1, U11.B5 (PB6), U13.4 (SCL)
/Baro_I2C1_SDA: R37.1, U11.A5 (PB7), U13.3 (SDA)
/EX_I2C4_SCL: J3.5, R29.1, U11.K10 (PD12)
/EX_I2C4_SDA: J3.6, R30.1, U11.J10 (PD13)
/EX_SPI3_MISO: J12.5, U11.A6 (PB4)
/EX_SPI3_MOSI: J12.4, U11.G5 (PB2)
/EX_SPI3_SCK: J12.6, U11.A7 (PB3)
/FRAM_SPI2_MISO: U11.H10 (PB14), U16.2 (DO(IO1))
/FRAM_SPI2_MOSI: U11.F3 (PC3_C), U16.5 (DI(IO0))
/FRAM_SPI2_SCK: U11.C7 (PD3), U16.6 (CLK)
/FRAM_SPI2_~CS: U11.D7 (PD4), U16.1 (~CS)
/LED_BLUE: D13.2 (A), U11.G10 (PB15)
/LED_GREEN: D14.2 (A), U11.G9 (PD11)
/LED_RED: D12.2 (A), U11.G8 (PD15)
/NRST: C33.1, R27.2, U11.E1 (NRST)
/SBUS: J2.6, J7.4, R23.2, U19.2
/SBUS_INV: R38.2, U11.H8 (PD14), U19.1
/SCLK: J11.5, U11.A9 (PA14)
/SDMMC1_CK: J10.5 (CLK), U11.C8 (PC12)
/SDMMC1_CMD: J10.3 (CMD), R33.1, U11.B7 (PD2)
/SDMMC1_D0: J10.7 (DAT0), R34.1, U11.F9 (PC8)
/SDMMC1_D1: J10.8 (DAT1), R35.1, U11.E9 (PC9)
/SDMMC1_D2: J10.1 (DAT2), R31.1, U11.B9 (PC10)
/SDMMC1_D3: J10.2 (DAT3/CD), R32.1, U11.B8 (PC11)
/SWDIO: J11.6, U11.A10 (PA13)
/TIM1_CH1: J6.3, U11.K5 (PE9)
/TIM1_CH2: J6.4, U11.H6 (PE11)
/TIM1_CH3: J6.5, U11.K6 (PE13)
/TIM1_CH4: J6.6, U11.G7 (PE14)
/TIM2_CH3: J8.4, U11.J7 (PB10)
/TIM2_CH4: J8.5, U11.K7 (PB11)
/TIM3_CH3: J8.3, U11.J4 (PB0)
/TIM3_CH4: J8.2, U11.K4 (PB1)
/UART4_RX: J5.4, U11.B4 (PB8)
/UART4_TX: J5.3, U11.A4 (PB9)
/UART5_RX: U11.K8 (PB12), U19.4
/UART5_TX: J7.3, U11.J8 (PB13)
/UART6_RX: U11.E10 (PC7)
/UART6_TX: U11.F10 (PC6)
/UART7_RX: J6.2, U11.H5 (PE7)
/UART7_TX: U11.J5 (PE8)
/UART8_RX: J11.4, U11.D4 (PE0)
/UART8_TX: J11.3, U11.C4 (PE1)
/USART1_CK: U11.D9 (PA8)
/USART1_RX: J3.4, U11.D10 (PA10)
/USART1_TX: J3.3, U11.C9 (PA9)
/USART2_CK: U11.D6 (PD7)
/USART2_RX: J4.4, U11.C6 (PD6)
/USART2_TX: J4.3, U11.B6 (PD5)
/USART3_CK: U11.H9 (PD10)
/USART3_RX: J2.4, U11.J9 (PD9)
/USART3_TX: J2.3, U11.K9 (PD8)
/USB_OTG_FS_DM: D2.2 (A2), J1.A7 (D-), J1.B7 (D-), J9.2, U11.C10 (PA11)
/USB_OTG_FS_DP: D4.2 (A2), J1.A6 (D+), J1.B6 (D+), J9.3, U11.B10 (PA12)
/VBUS: C9.1, C11.1, D1.2 (A2), D5.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J9.1
CAM_9V: C25.1, C26.1, D11.2 (A), J2.1, L2.2, R17.2, TP12.1
Core_3V3: BOOT1.1, C14.1, C16.1, C19.1, C29.2, C31.1, C32.1, C34.1, C38.1, C40.1, C41.1, C42.1, C44.1, C45.1, D8.2 (A), R27.1, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, TP2.1, U2.5 (VOUT), U11.B2 (VBAT), U11.D2 (VDD), U11.D8 (PD0), U11.F4 (VDDLDO), U11.F5 (VDD), U11.F6 (VDD33USB), U11.F7 (PDR_ON), U11.H1 (VDDA), U11.K1 (VDD), U13.6 (VDDIO), U13.8 (VDD), U14.3 (VDD), U14.11 (VDDIO), U15.3 (VDD), U15.11 (VDDIO), U19.5 (VCC), Y1.1 (~ST), Y1.4 (VCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.1, C28.1, C29.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.1, C44.2, C45.2, D1.1 (A1), D2.1 (A1), D3.1 (A1), D4.1 (A1), H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J2.5, J2.MP (MountPin), J3.1, J3.MP (MountPin), J4.1, J4.MP (MountPin), J5.1, J5.MP (MountPin), J6.8, J6.MP (MountPin), J7.1, J7.MP (MountPin), J8.1, J8.MP (MountPin), J9.4, J10.6 (VSS), J10.9 (SHIELD), J11.1, J11.MP (MountPin), J12.MP (MountPin), R1.1, R2.1, R7.2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
unnamed: C17.1, R8.2
unnamed: C21.1, R10.2
unnamed: C27.2, U11.E7 (VCAP)
unnamed: C28.2, U11.F8 (VCAP)
unnamed: D6.2 (A), Q1.1 (G), R7.1
unnamed: D8.1 (K), R18.2
unnamed: D9.1 (K), R19.2
unnamed: D10.1 (K), R20.2
unnamed: D11.1 (K), R21.2
unnamed: D12.1 (K), R24.1
unnamed: D13.1 (K), R25.1
unnamed: D14.1 (K), R26.1
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.B5 (CC2), R1.2
unnamed: R9.2, R11.2, R13.1
unnamed: R12.2, R16.2, R17.1
unnamed: R8.1, U1.4 (BST)
unnamed: R3.2, U1.3 (EN/SYNC)
unnamed: R9.1, U1.1 (FB)
unnamed: R4.2, U1.8 (PG)
unnamed: C17.2, L1.1, U1.6 (SW)
unnamed: C7.1, R4.1, U1.2 (VCC)
unnamed: R10.1, U4.4 (BST)
unnamed: R5.2, U4.3 (EN/SYNC)
unnamed: R12.1, U4.1 (FB)
unnamed: R6.2, U4.8 (PG)
unnamed: C21.2, L2.1, U4.6 (SW)
unnamed: C10.1, R6.1, U4.2 (VCC)
unnamed: C35.1, U11.A1 (PC14-OSC32_IN), Y2.2
unnamed: C36.1, U11.B1 (PC15-OSC32_OUT), Y2.1
unnamed: BOOT1.2, R28.2, U11.D5 (BOOT0)
unnamed: C30.1, U11.C1 (PH0-OSC_IN), Y1.3 (OUT)
Periph_3V3: C15.1, C18.1, C20.1, C37.1, C39.1, C43.2, D9.2 (A), J10.4 (VDD), TP5.1, U3.5 (VOUT), U16.3 (IO2), U16.7 (IO3), U16.8 (VCC)
System_4V5: C5.1, C6.1, D5.1 (K), D7.1 (K), U2.1 (VIN), U2.3 (EN), U3.1 (VIN), U3.3 (EN)
System_5V: C23.1, C24.1, D7.2 (A), D10.2 (A), J3.2, J4.2, J5.2, J7.2, J11.2, L1.2, R13.2, TP3.1, TP4.1, TP6.1, TP7.1, TP9.1
VCC_24V: C1.1, C2.1, C3.1, C4.1, C8.1, D6.1 (K), Q1.2 (S), R3.1, R5.1, R14.1, TP1.1, U1.7 (IN), U4.7 (IN)
VCC_BAT: C12.1, C13.1, D3.2 (A2), J6.7, Q1.3 (D)

Notes on the sheet:
9V 3A output
power up singal to tirgger qgroundcontrol bootloader sync
6.3V 耐压即可
7.68kR 5V output
SPL06 Baro I2C1
BAT_Voltage_Detection
If 0R is connected UART5 RX is used as SBUS
IMU BMI088 SPI1
防反接
SDO To VSS ADDR:0x1110110 SDO To VDDIO ADDR:0x1110111 CSB To VDDIO In I2C Mode
If want to utilize UART8 in PX4, make UART6 as the debug port
2S-6S input to 5V
冲击保护
3.3V 500mA MCU IMU Power
5V to Periph_VCC
Sbus
9V/10V to drive CAM
此处的电流一般不会超过5A
没有使用，将滤波工作交给O3
Cap should be 10% X5R Res should be 1% 注释电压都是最低要求 或者这个封装能找到的可用的 板子适配DJI O3 天空端
IMU BMI088 SPI4
Buzzer
FRAM / QSPI
ADR for accel data ready GDR for gyro data ready ACS for accel cs GCS for gyro cs
BAT power
3.3V 500mA TF-Card QSPI OSD
IO GH2.5
MCU
BAT power protection
SD_CARD
DJI O3
5V 3A output
3.54k output 10V 4.02k output 9V 2.9k for 12V
5V to Core_VCC
Type-C power
2S-6S input to 9V

Board: 4 copper layers, 33.0 x 27.0 mm, 137 parts (65 on the bottom side), 109 nets.

File NxtPX4_Pro_V1.0.1_Release/NxtPX4_Pro_V1.0.1_Release_production/NxtPX4_Pro_V1.0.1_Release_bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BOOT1,3x2.5PushButton,1,TD-1183SN-1.5H(3x2.5),
C1,0805,1,22uF(0805 35V 20%),
C10,0201,1,100nF(0201 10V 10%),
C11,0201,1,100nF(0201 16V 10%),
C12,0805,1,22uF(0805 35V 20%),
C13,0805,1,22uF(0805 35V 20%),
C14,0402,1,1uF(0402 10V 10%),
C15,0402,1,1uF(0402 10V 10%),
C16,0201,1,100nF(0201 10V 10%),
C17,0201,1,100nF(0201 25V 10%),
C18,0201,1,100nF(0201 10V 10%),
C19,0201,1,100nF(0201 10V 10%),
C2,0603,1,10uF(0603 35V 20%),
C20,0201,1,100nF(0201 10V 10%),
C21,0201,1,100nF(0201 25V 10%),
C22,0201,1,100nF(0201 10.0V 10%),
C23,0603,1,22uF(0603 16V),
C24,0603,1,22uF(0603 16V),
C26,0603,1,22uF(0603 16V),
C27,0402,1,2.2uF(0402 6.3V 10%),
C28,0402,1,2.2uF(0402 6.3V 10%),
C29,0402,1,4.7uF(0402 10V),
C3,0805,1,22uF(0805 35V 20%),
C30,0201,1,15pF(0201 10V),
C31,0201,1,100nF(0201 6.3V),
C32,0201,1,1uF(0201 6.3V),
C33,0201,1,100nF(0201 10V 10%),
C34,0201,1,100nF(0201 10V 10%),
C35,0201,1,12.0pF(0201 10V),
C36,0201,1,12.0pF(0201 10V),
C37,0201,1,100nF(0201 10V 10%),
C38,0201,1,100nF(0201 10V 10%),
C39,0201,1,10nF(0201 10V 10%),
C4,0402,1,1uF(0402 35V 10%),
C40,0201,1,100nF(0201 10V 10%),
C41,0201,1,2.2uF(0201 10V 10%),
C42,0201,1,100nF(0201 10V 10%),
C43,0201,1,10nF(0201 10V 10%),
C44,0201,1,100.0nF(0201 10V),
C45,0201,1,100nF(0201 10V),
C46,0201,1,100nF(0201 10V),
C47,0201,1,100.0nF(0201 10V),
C48,0201,1,100nF(0201 10V 10%),
C49,0201,1,100nF(0201 10V),
C5,0402,1,1uF(0402 16V 10%),
C6,0402,1,1uF(0402 16V 10%),
C7,0201,1,100nF(0201 10V 10%),
C8,0402,1,1uF(0402 35V 10%),
C9,0402,1,1uF(0402 16V 10%),
D1,PESD12VV1BL_315,1,PESD12VV1BL,
D10,0201,1,LED_Blue(0201),
D11,0201,1,LED_Blue(0201),
D12,0201,1,LED_RED(0201),
D13,0201,1,LED_BLUE(0201),
D14,0201,1,LED_Green(0201),
"D2, D4",PESD5V0F1BL,2,PESD5V0F1BL,
D3,D_SOD-123F,1, SMF30CA(30V),
"D5, D7",D_SOD-123F,2,DSS34(3A 500mV),
D6,D_SOD-523,1,BZX584C9V1,
D8,0201,1,LED_Blue(0201),
D9,0201,1,LED_Blue(0201),
J1,USB_C_Small,1,USB_C_Receptacle_USB2.0,
J10,01x10_MP_sh1.0_Hori,1,ESC,
J24,TF-SMD_TF-021B-H265,1,Micro_SD_Card,
J9,01x04_sh1.0,1,Upper computer connector,
"L1, L2",Inductor_0420,2,10uH(0420),
Q1,SOT-23,1,AP40P05,
"Q2, Q3",SOT-23,2,SS8050(NPN BEC),
R1,0201,1,5.1kR(0201),
R10,0201,1,51kR(0201 25V),
R11,0201,1,20R(0201 25V),
R12,0201,1,7.68kR(0201 25V),
R13,0201,1,51kR(0201 25V),
R14,0201,1,41.2kR(0201 25V),
R15,0201,1,200.0kR(0201 50V),
R16,0201,1,22.0kR(0201 50V),
R17,0201,1,3.54k-4.02kR(0201 25V),
R18,0201,1,41.2kR(0201 25V),
R19,0201,1,10kR(0201),
R2,0201,1,5.1kR(0201),
R20,0201,1,10kR(0201),
R21,0201,1,10kR(0201),
R22,0201,1,20kR(0201 9V),
R23,0201,1,1kR(0201),
R24,0201,1,4.7kR(0201 25V),
R25,0201,1,4.7kR(0201 25V),
R26,0201,1,10kR(0201),
R28,0201,1,100R(0201),
R29,0201,1,1kR(0201),
R3,0201,1,100kR(0201 50V),
R30,0201,1,10kR(0201),
R31,0201,1,10kR(0201),
R32,0201,1,10.0kR(0201),
R33,0201,1,10.0kR(0201),
R34,0201,1,10.0kR(0201),
R35,0201,1,4.7kR(0201),
R36,0201,1,4.7kR(0201),
R37,0201,1,10kR(0201),
R38,0201,1,10kR(0201),
R39,0201,1,10kR(0201),
R4,0402,1,1MR(0402 50V),
R40,0201,1,10kR(0201),
R41,0201,1,10kR(0201),
R5,0201,1,100kR(0201 25V),
R6,0402,1,1MR(0402 50V),
R7,0201,1,100kR(0201 25V),
R8,0201,1,100kR(0201 50V),
R9,0201,1,20R(0201 25V),
"U1, U4",MP9943GQ-Z,2,MP9943GQ-Z,
U10,BMI088,1,BMI088,
U11,ICM-20602,1,ICM-20602,
U12,MPU-6500,1,MPU6500,
U13,PQFN50P200X200X80-10N,1,BMP388,
U14,SOIC-8_5.23x5.23mm_P1.27mm,1,W25Q128JVS,
"U2, U3",RT9013-33GB,2,RT9013-33GB,
U9,STM32H743VIHBGA100C80P10X10_800X800X110N,1,STM32H743VIH6,
Y1,Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm,1,SG-210STF/ X1G004171002700,
Y2,LSE(2012),1,ABS07 (32.768kHZ),

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
